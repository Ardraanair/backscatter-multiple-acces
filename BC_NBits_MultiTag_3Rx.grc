options:
  parameters:
    generate_options: qt_gui
    id: BC_1
    output_language: python
    title: Backscatter Communication
  states: {}

blocks:
- name: ambient_carrier
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: delay_bb
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '50'
    stop: 10 * sps
    value: '16000'
  states: {}
- name: pathloss_ambient_rx_direct
  id: variable
  parameters:
    value: '0.0414'
  states: {}
- name: pathloss_ambient_tag
  id: variable
  parameters:
    value: '0.0414'
  states: {}
- name: pathloss_tag_rx
  id: variable
  parameters:
    value: '0.01166'
  states: {}
- name: rf_switch_freq
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: rf_switch_freq_1
  id: variable
  parameters:
    value: '800'
  states: {}
- name: rf_switch_freq_2
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: rx_bpf_f1
  id: variable
  parameters:
    value: ambient_carrier + rf_switch_freq - 4 / symbol_time
  states: {}
- name: rx_bpf_f1_t2
  id: variable
  parameters:
    value: ambient_carrier + rf_switch_freq_1 - 4 / symbol_time
  states: {}
- name: rx_bpf_f1_t3
  id: variable
  parameters:
    value: ambient_carrier + rf_switch_freq_2 - 4 / symbol_time
  states: {}
- name: rx_bpf_f2
  id: variable
  parameters:
    value: ambient_carrier + rf_switch_freq + 4 / symbol_time
  states: {}
- name: rx_bpf_f2_t2
  id: variable
  parameters:
    value: ambient_carrier + rf_switch_freq_1 + 4 / symbol_time
  states: {}
- name: rx_bpf_f2_t3
  id: variable
  parameters:
    value: ambient_carrier + rf_switch_freq_2 + 4 / symbol_time
  states: {}
- name: rx_bpf_tw
  id: variable
  parameters:
    value: 4 / symbol_time
  states: {}
- name: rx_noise_std
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0'
  states: {state: disabled}
- name: rx_noise_std
  id: variable
  parameters:
    value: '0.0000279'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(symbol_time * samp_rate)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1/symbol_time
  states: {}
- name: symbol_time
  id: variable
  parameters:
    value: '50e-3'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_0_t2
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_agc_xx_0_t3
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: rx_noise_std
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ambient_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rf_switch_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rf_switch_freq_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: rf_switch_freq_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ambient_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: ambient_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: rx_bpf_f2
    low_cutoff_freq: rx_bpf_f1
    samp_rate: samp_rate
    type: fir_filter_fff
    width: rx_bpf_tw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: rx_bpf_f2
    low_cutoff_freq: rx_bpf_f1
    samp_rate: samp_rate
    type: fir_filter_fff
    width: rx_bpf_tw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_t2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: rx_bpf_f2_t2
    low_cutoff_freq: rx_bpf_f1_t2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: rx_bpf_tw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_t3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: rx_bpf_f2_t3
    low_cutoff_freq: rx_bpf_f1_t3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: rx_bpf_tw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_t2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: rx_bpf_f2_t2
    low_cutoff_freq: rx_bpf_f1_t2
    samp_rate: samp_rate
    type: fir_filter_fff
    width: rx_bpf_tw
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_t3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '100'
    high_cutoff_freq: rx_bpf_f2_t3
    low_cutoff_freq: rx_bpf_f1_t3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: rx_bpf_tw
    win: window.WIN_HAMMING
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_t2
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_t3
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_t2
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_t3
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_3
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_bb
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(sps/2)
    type: float
  states: {}
- name: blocks_delay_0_0_t2
  id: blocks_delay
  parameters:
    delay: int(sps/2)
    type: float
  states: {}
- name: blocks_delay_0_0_t3
  id: blocks_delay
  parameters:
    delay: int(sps/2)
    type: float
  states: {}
- name: blocks_delay_0_t2
  id: blocks_delay
  parameters:
    delay: delay_bb
    type: float
  states: {}
- name: blocks_delay_0_t3
  id: blocks_delay
  parameters:
    delay: delay_bb
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate * 10
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate * 10
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pathloss_tag_rx
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pathloss_tag_rx
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: pathloss_tag_rx
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: pathloss_ambient_rx_direct
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_t2
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0_t3
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_t2
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_t3
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[1]*int(sps) + [1]*int(sps) + [0]*int(sps) + [0]*int(sps)'
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1,1,1,0,1,0,1,0]'
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1,0,0,1,1,0,1]'
  states: {}
- name: blocks_vector_source_x_3
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0,1,1,0,1,0,0,1,1,1,0]'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '5000'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_t2
  id: dc_blocker_xx
  parameters:
    length: '5000'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_t3
  id: dc_blocker_xx
  parameters:
    length: '5000'
    long_form: 'True'
    type: ff
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_t2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_0_t3
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_t2
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0_t3
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_t2
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: digital_symbol_sync_xx_0_t3
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.power(10, input_items[0])
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sigma_on = 1.0, sigma_off = 0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BackScatter Tag',   # will show up in GRC
                  in_sig=[(np.float32), (np.float32)],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sigma_on = sigma_on
              self.sigma_off = sigma_off

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              temp = self.sigma_on * (input_items[1] > 0.5) + self.sigma_off * (input_items[1] <= 0.5)
              output_items[0][:] = temp * input_items[0]
              return len(output_items[0])
    sigma_off: '0.000174'
    sigma_on: '0.001385'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sigma_on = 1.0, sigma_off = 0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BackScatter Tag',   # will show up in GRC
                  in_sig=[(np.float32), (np.float32)],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sigma_on = sigma_on
              self.sigma_off = sigma_off

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              temp = self.sigma_on * (input_items[1] > 0.5) + self.sigma_off * (input_items[1] <= 0.5)
              output_items[0][:] = temp * input_items[0]
              return len(output_items[0])
    sigma_off: '0.000174'
    sigma_on: '0.001385'
  states: {}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sigma_on = 1.0, sigma_off = 0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='BackScatter Tag',   # will show up in GRC
                  in_sig=[(np.float32), (np.float32)],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.sigma_on = sigma_on
              self.sigma_off = sigma_off

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              temp = self.sigma_on * (input_items[1] > 0.5) + self.sigma_off * (input_items[1] <= 0.5)
              output_items[0][:] = temp * input_items[0]
              return len(output_items[0])
    sigma_off: '0.000174'
    sigma_on: '0.001385'
  states: {}
- name: epy_block_0_t2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.power(10, input_items[0])
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: epy_block_0_t3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = np.power(10, input_items[0])
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_t2
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fec_ber_bf_0_t3
  id: fec_ber_bf
  parameters:
    berminerrors: '10000'
    test_mode: 'False'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/sps]*int(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_t2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/sps]*int(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_0_t3
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/sps]*int(sps)'
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '[1]'
    type: fff
  states: {}
- name: fir_filter_xxx_1_t2
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '[1]'
    type: fff
  states: {}
- name: fir_filter_xxx_1_t3
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: '[1]'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '[1]*sps'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_2
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '[1]*sps'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_3
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: '[1]*sps'
    type: fff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2 * symbol_rate
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_t2
  id: low_pass_filter
  parameters:
    cutoff_freq: 2 * symbol_rate
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_t3
  id: low_pass_filter
  parameters:
    cutoff_freq: 2 * symbol_rate
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: Receive Spectrum Rx BPF OP
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: BER Tag 1
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: Backscatter Power
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: Noise Power
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: Inst. SNR
    type: float
  states: {}
- name: qtgui_number_sink_0_t2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: BER Tag 2
    type: float
  states: {}
- name: qtgui_number_sink_0_t3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: BER Tag 3
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Tag 1 symbols"'
    size: '64'
    srate: samp_rate / int(sps)
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_t2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Tag 2 symbols"'
    size: '64'
    srate: samp_rate / int(sps)
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_t3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Tag 3 symbols"'
    size: '64'
    srate: samp_rate / int(sps)
    stemplot: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Input baseband
    label2: Energy detector (abs)
    label3: LPF
    label4: Matched Filter Output
    label5: AGC O/P
    name: Tag 1 (1000 Hz) - Time domain signals
    nconnections: '5'
    size: '80000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_t2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Input baseband
    label2: Energy detector (abs)
    label3: LPF
    label4: Matched Filter Output
    label5: AGC O/P
    name: Tag 2 (800 Hz) - Time domain signals
    nconnections: '5'
    size: '80000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1_t3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Input baseband
    label2: Energy detector (abs)
    label3: LPF
    label4: Matched Filter Output
    label5: AGC O/P
    name: Tag 3 (1200 Hz) - Time domain signals
    nconnections: '5'
    size: '80000'
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mod_baseband
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: bits_out
  states: {}
- name: virtual_sink_1_t2
  id: virtual_sink
  parameters:
    stream_id: bits_out_t2
  states: {}
- name: virtual_sink_1_t3
  id: virtual_sink
  parameters:
    stream_id: bits_out_t3
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: mod_baseband_2
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: mod_baseband_3
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mod_baseband
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: mod_baseband
  states: {}
- name: virtual_source_0_0_t2
  id: virtual_source
  parameters:
    stream_id: mod_baseband_2
  states: {}
- name: virtual_source_0_0_t3
  id: virtual_source
  parameters:
    stream_id: mod_baseband_3
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: mod_baseband_2
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: mod_baseband_3
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: bits_out
  states: {}
- name: virtual_source_1_t2
  id: virtual_source
  parameters:
    stream_id: bits_out_t2
  states: {}
- name: virtual_source_1_t3
  id: virtual_source
  parameters:
    stream_id: bits_out_t3
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_1, '4']
- [analog_agc_xx_0_t2, '0', digital_symbol_sync_xx_0_t2, '0']
- [analog_agc_xx_0_t2, '0', qtgui_time_sink_x_0_1_t2, '4']
- [analog_agc_xx_0_t3, '0', digital_symbol_sync_xx_0_t3, '0']
- [analog_agc_xx_0_t3, '0', qtgui_time_sink_x_0_1_t3, '4']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_noise_source_x_0, '0', blocks_multiply_xx_1_0, '0']
- [analog_noise_source_x_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [analog_sig_source_x_0, '0', epy_block_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_1, '0', epy_block_0_0_0, '0']
- [analog_sig_source_x_0_1_0, '0', epy_block_0_0_0_0, '0']
- [band_pass_filter_0, '0', band_pass_filter_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_abs_xx_0, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [band_pass_filter_0_0_t2, '0', blocks_abs_xx_0_t2, '0']
- [band_pass_filter_0_0_t3, '0', blocks_abs_xx_0_t3, '0']
- [band_pass_filter_0_t2, '0', band_pass_filter_0_0_t2, '0']
- [band_pass_filter_0_t3, '0', band_pass_filter_0_0_t3, '0']
- [blocks_abs_xx_0, '0', low_pass_filter_0, '0']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_abs_xx_0_t2, '0', low_pass_filter_0_t2, '0']
- [blocks_abs_xx_0_t2, '0', qtgui_time_sink_x_0_1_t2, '1']
- [blocks_abs_xx_0_t3, '0', low_pass_filter_0_t3, '0']
- [blocks_abs_xx_0_t3, '0', qtgui_time_sink_x_0_1_t3, '1']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0_0, '0']
- [blocks_add_const_vxx_0_t2, '0', digital_binary_slicer_fb_0_0_t2, '0']
- [blocks_add_const_vxx_0_t3, '0', digital_binary_slicer_fb_0_0_t3, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0_t2, '0']
- [blocks_add_xx_0, '0', band_pass_filter_0_t3, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_2, '0', interp_fir_filter_xxx_2, '0']
- [blocks_char_to_float_3, '0', interp_fir_filter_xxx_3, '0']
- [blocks_delay_0, '0', blocks_delay_0_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_delay_0_0, '0', fir_filter_xxx_1, '0']
- [blocks_delay_0_0_t2, '0', fir_filter_xxx_1_t2, '0']
- [blocks_delay_0_0_t3, '0', fir_filter_xxx_1_t3, '0']
- [blocks_delay_0_t2, '0', blocks_delay_0_0_t2, '0']
- [blocks_delay_0_t2, '0', qtgui_time_sink_x_0_1_t2, '0']
- [blocks_delay_0_t3, '0', blocks_delay_0_0_t3, '0']
- [blocks_delay_0_t3, '0', qtgui_time_sink_x_0_1_t3, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', epy_block_0_0, '1']
- [blocks_multiply_xx_0_0, '0', epy_block_0_0_0, '1']
- [blocks_multiply_xx_0_0_0, '0', epy_block_0_0_0_0, '1']
- [blocks_multiply_xx_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_xx_1_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', fec_ber_bf_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', fec_ber_bf_0, '1']
- [blocks_unpacked_to_packed_xx_0_0_t2, '0', fec_ber_bf_0_t2, '1']
- [blocks_unpacked_to_packed_xx_0_0_t3, '0', fec_ber_bf_0_t3, '1']
- [blocks_unpacked_to_packed_xx_0_t2, '0', fec_ber_bf_0_t2, '0']
- [blocks_unpacked_to_packed_xx_0_t3, '0', fec_ber_bf_0_t3, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_vector_source_x_1, '0', blocks_char_to_float_0, '0']
- [blocks_vector_source_x_2, '0', blocks_char_to_float_2, '0']
- [blocks_vector_source_x_3, '0', blocks_char_to_float_3, '0']
- [dc_blocker_xx_0, '0', fir_filter_xxx_0, '0']
- [dc_blocker_xx_0_t2, '0', fir_filter_xxx_0_t2, '0']
- [dc_blocker_xx_0_t3, '0', fir_filter_xxx_0_t3, '0']
- [digital_binary_slicer_fb_0, '0', virtual_sink_1, '0']
- [digital_binary_slicer_fb_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_binary_slicer_fb_0_0_t2, '0', blocks_unpacked_to_packed_xx_0_t2, '0']
- [digital_binary_slicer_fb_0_0_t3, '0', blocks_unpacked_to_packed_xx_0_t3, '0']
- [digital_binary_slicer_fb_0_t2, '0', virtual_sink_1_t2, '0']
- [digital_binary_slicer_fb_0_t3, '0', virtual_sink_1_t3, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0_t2, '0', digital_binary_slicer_fb_0_t2, '0']
- [digital_symbol_sync_xx_0_t2, '0', qtgui_time_sink_x_0_0_t2, '0']
- [digital_symbol_sync_xx_0_t3, '0', digital_binary_slicer_fb_0_t3, '0']
- [digital_symbol_sync_xx_0_t3, '0', qtgui_time_sink_x_0_0_t3, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [epy_block_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [epy_block_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [epy_block_0_t2, '0', qtgui_number_sink_0_t2, '0']
- [epy_block_0_t3, '0', qtgui_number_sink_0_t3, '0']
- [fec_ber_bf_0, '0', epy_block_0, '0']
- [fec_ber_bf_0_t2, '0', epy_block_0_t2, '0']
- [fec_ber_bf_0_t3, '0', epy_block_0_t3, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_1, '3']
- [fir_filter_xxx_0_t2, '0', analog_agc_xx_0_t2, '0']
- [fir_filter_xxx_0_t2, '0', qtgui_time_sink_x_0_1_t2, '3']
- [fir_filter_xxx_0_t3, '0', analog_agc_xx_0_t3, '0']
- [fir_filter_xxx_0_t3, '0', qtgui_time_sink_x_0_1_t3, '3']
- [fir_filter_xxx_1, '0', blocks_add_const_vxx_0, '0']
- [fir_filter_xxx_1_t2, '0', blocks_add_const_vxx_0_t2, '0']
- [fir_filter_xxx_1_t3, '0', blocks_add_const_vxx_0_t3, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_2, '0', virtual_sink_2, '0']
- [interp_fir_filter_xxx_3, '0', virtual_sink_3, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_1, '2']
- [low_pass_filter_0_t2, '0', dc_blocker_xx_0_t2, '0']
- [low_pass_filter_0_t2, '0', qtgui_time_sink_x_0_1_t2, '2']
- [low_pass_filter_0_t3, '0', dc_blocker_xx_0_t3, '0']
- [low_pass_filter_0_t3, '0', qtgui_time_sink_x_0_1_t3, '2']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_0, '0', blocks_delay_0, '0']
- [virtual_source_0_0_t2, '0', blocks_delay_0_t2, '0']
- [virtual_source_0_0_t3, '0', blocks_delay_0_t3, '0']
- [virtual_source_0_1, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_0_1_0, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_1, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [virtual_source_1_t2, '0', blocks_unpacked_to_packed_xx_0_0_t2, '0']
- [virtual_source_1_t3, '0', blocks_unpacked_to_packed_xx_0_0_t3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
